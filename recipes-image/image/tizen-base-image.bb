require tizen-base-image.inc

IMAGE_INSTALL += "screen"
IMAGE_INSTALL += "strace"
IMAGE_INSTALL += "rsync"
