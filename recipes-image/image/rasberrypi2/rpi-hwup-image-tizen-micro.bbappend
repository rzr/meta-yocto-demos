include ../generic-image-tizen-micro.inc
