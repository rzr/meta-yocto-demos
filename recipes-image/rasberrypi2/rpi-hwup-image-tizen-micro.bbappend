#include ../generic-image-tizen-micro.inc
include ../oic-image.inc
PREFERRED_PROVIDER_virtual/sshd = "ssh-server-openssh"
