FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

#
# specifying additional kernel feature
#
SRC_URI += "file://bluetooth.cfg"
