SECTION = "Network & Connectivity/Libraries"

BBCLASSEXTEND += "native"
