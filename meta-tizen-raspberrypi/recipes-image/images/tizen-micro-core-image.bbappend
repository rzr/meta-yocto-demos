require recipes-core/images/rpi-hwup-image.bb
