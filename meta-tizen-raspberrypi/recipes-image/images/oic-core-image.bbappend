require recipes-image/images/rpi-hwup-image.bb
