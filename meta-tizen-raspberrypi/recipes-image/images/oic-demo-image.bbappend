require tizen-common-core-image-minimal.bb

IMAGE_INSTALL += "weston-clients"
IMAGE_BASE_INSTALL += "python-smartpm"
IMAGE_INSTALL += "elementary-tools"
